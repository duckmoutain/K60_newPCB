# Keil uVision project TEST.uvprojx, settings and files
target MK60DN512 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60D10
  c misc: --c99
  c include: ..\drivers;..\drivers\core;..\drivers\startup;..\hardware;..\application
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group drivers
    ../drivers/: adc.c adc.h arm_common_tables.h arm_const_structs.h arm_math.h can.c can.h chlib_k.h cmp.c cmp.h common.c common.h cpuidy.c cpuidy.h crc.c crc.h dac.c dac.h dma.c dma.h dsp_demo.h enet.c enet.h flash.c flash.h flexbus.c flexbus.h ftm.c ftm.h gpio.c gpio.h i2c.c i2c.h i2s.c i2s.h lptmr.c lptmr.h nfc.c nfc.h pdb.c pdb.h pit.c pit.h rtc.c rtc.h sd.c sd.h spi.c spi.h systick.c systick.h tsi.c tsi.h uart.c uart.h vref.c vref.h wdog.c wdog.h
    ../drivers/startup/: armcc_startup_MK60D10.s
    ../drivers/core/: system_MK60D10.c
  group hardware
    ../hardware/: communicate.c motor.c oled.c key.c
  group application
    ../application/: main.c menu.c control.c
